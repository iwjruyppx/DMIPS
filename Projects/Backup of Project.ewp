# IAR project Backup of Project.ewp, settings and files
configuration STM32F4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; USE_STM32F4_EVB; STM32F4XX; STM32F401X; __VERBOSE; DEBUG
  ICCARM.CCDiagSuppress: Pa082, pe191,Pa050
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32_Common; ..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F4xx_HAL_Driver\inc; ..\..\..\Libraries\CMSIS\Device\STM32F4xx\Include; ..\..\..\..\FreeRTOS\FreeRTOS821\Source\include; ..\..\..\..\FreeRTOS\FreeRTOS821\Source\portable\IAR\ARM_CM4F; ..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\Libraries\STM32_CPAL_Driver\devices\stm32f4xx; ..\..\..\..\System\Algorithm\inc; ..\..\..\..\System\Driver\inc; ..\..\..\..\System\DriverLibrary\AKM8963\inc; ..\..\..\..\System\DriverLibrary\AKM09911\inc; ..\..\..\..\System\DriverLibrary\AKM09911AG\; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_HAL; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library\libag; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library\libSmartCompass; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Sensors; ..\..\..\..\System\DriverLibrary\MMC3524xPJ; ..\..\..\..\System\DriverLibrary\ST480M; ..\..\..\..\System\DriverLibrary\Yamaha\inc; ..\..\..\..\System\DriverLibrary\YamahaMini\inc; ..\..\..\..\System\DriverLibrary\EPL2197\inc; ..\..\..\..\System\DriverLibrary\PM131; ..\..\..\..\System\DriverLibrary\TMG4903\GestureLib_v211\inc; ..\..\..\..\System\Manager\inc; ..\..\..\..\System\Utils\inc; ..\..\..\Release\Driver\inc; ..\..\..\Release\Manager\inc; ..\..\..\Release\Platform\inc; ..\..\..\Release\RtosTask\inc; ..\..\..\Release\System\inc; ..\..\..\Release\SystemConfig\inc; ..\..\..\Algo; ..\..\..\Algo\GoldSample; ..\..\..\Algo\object; ..\..\..\Dmps; ..\..\..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\Release\Platform\inc; ..\..\..\
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash_EEPROM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CyweeLib (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; USE_STM32F4_EVB; STM32F4XX; STM32F401X; STM32F401X
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32_Common; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\STM32F4xx\Include; ..\..\..\..\FreeRTOS\FreeRTOS821\Source\include; ..\..\..\..\FreeRTOS\FreeRTOS821\Source\portable\IAR\ARM_CM4F; ..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\Libraries\STM32_CPAL_Driver\devices\stm32f4xx; ..\..\..\..\System\Algorithm\inc; ..\..\..\..\System\Driver\inc; ..\..\..\..\System\DriverLibrary\AKM8963\inc; ..\..\..\..\System\DriverLibrary\AKM09911\inc; ..\..\..\..\System\DriverLibrary\AKM09911AG\; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_HAL; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library\libag; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Library\libSmartCompass; ..\..\..\..\System\DriverLibrary\AKM09911AG\AKM_Sensors; ..\..\..\..\System\DriverLibrary\MMC3524xPJ; ..\..\..\..\System\DriverLibrary\ST480M; ..\..\..\..\System\DriverLibrary\Yamaha\inc; ..\..\..\..\System\DriverLibrary\YamahaMini\inc; ..\..\..\..\System\Manager\inc; ..\..\..\..\System\Utils\inc; ..\..\..\Release\Driver\inc; ..\..\..\Release\Manager\inc; ..\..\..\Release\Platform\inc; ..\..\..\Release\RtosTask\inc; ..\..\..\Release\System\inc; ..\..\..\Release\SystemConfig\inc
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: ..\..\..\Release\Platform\inc; ..\..\..\Release\System\inc
  ILINK.IlinkAdditionalLibs: ..\..\..\Release\lib\ATT1C7NC.LIB
configuration CyweeRelease (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; USE_STM32F4_EVB; STM32F4XX; STM32F401X; STM32F401X; AKM_MAGNETOMETER_AK09911; AKSC_VERSION_DEVICE=9911; AKL_SKIP_HW_CHECK; DEBUG; AKM_DISABLE_DOEPLUS; AKM_CUSTOM_CONTINUOUS_MEASURE; DOEAG_MODE_EN; ACC_SENSOR_DISABLE; AKM_ACCELEROMETER_DUMMY; __AKM_ENABLE_PDC
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkAdditionalLibs: ..\..\..\Release\lib\ATT1C7NC.LIB; ..\..\..\Release\lib\CyweeMotion.a; ..\..\..\Release\lib\AKM09911.a
  group ALGO
    ../../../Algo/: AlgorithmHal.c
  group ALGO/Object
    ../../../Algo/object/: cwm_pick_up.o cwm_pick_up_api.c
  group DMPS
    ../../../Dmps/: Dmps.c
  group GoldSample
    ../../../Algo/GoldSample/: GoldSample.c
  group Main
    ../../../: main.c stm32xxx_it.c
  group Main/CMSIS/STM32F4XX
    ../../../Libraries/CMSIS/Device/STM32F4xx/Source/Templates/iar/: startup_stm32f401x.s
    ../../../Libraries/CMSIS/Device/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Main/STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
